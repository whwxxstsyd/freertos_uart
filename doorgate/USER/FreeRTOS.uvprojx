# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\MALLOC;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\TASK;..\USERLIB;..\INCLUDE;..\HARDWARE\PLATFORM;..\MEM;..\PROTOCAL;..\HARDWARE\BEEP;..\HARDWARE\SD2068;..\HARDWARE\CARD;..\CARD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c app.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PLATFORM/: platform.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SD2068/: calendar.c sd2068.c
    ../HARDWARE/CARD/: card.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group TASK
    ../TASK/: mp_uart_task.c mp_idle_task.c mp_memory_task.c mp_card_task.c mp_door_task.c
  group USERLIB
    ../USERLIB/: BasicFunc.c mp_uart.c mp_osal_rtos.c mp_protocol_hostif.c param_base.c
  group MEM
    ../MEM/: mp_mem.c
  group PROTOCOL
    ../PROTOCAL/: Protocol.c ProtocolBase.c
  group CARD_LIB
    ../CARD/: CardLibrary.c CardPostProtocol.c Keynum.c Password.c ReadCard.c Wiegand.c
